# Keil uVision project HC32F4A0RGTB.uvprojx, settings and files
target HC32F4A0RGTB_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F4A0RGTB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HC32F4A0RGTB
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F4A0
  c misc: --diag_suppress=186,66
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x03000000 size 0x1800
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f4a0rgtb.s
    ../../common/: system_hc32f4a0rgtb.c
  group source
    ../source/: main.c
target HC32F4A0RGTB_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F4A0RGTB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800)  IRAM(0x1FFE0000,0x80000)  IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: HC32F4A0RGTB +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F4A0
  c misc: --diag_suppress=186,66
  c include: ..\..\common;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1FFE0000 size 0x80000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
