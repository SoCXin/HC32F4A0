# IAR project HC32F4A0TIHB.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F4A0
  ICCARM.CCIncludePath2: ..\..\common; ..\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f4a0tihb.srec
  ILINK.IlinkOutputFile: hc32f4a0tihb.out
  ILINK.IlinkIcfFile: config\HC32F4A0xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F4A0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group common
    ../../common/: system_hc32f4a0tihb.c
    ./: startup_hc32f4a0tihb.s
  group source
    ../source/: main.c
